# Keil uVision project Mark_TA.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Mark_TA +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Mark_TA
    ./: STARTUP.A51 Mark_TA.c pt6311.c delay.c uart.c ds3231.c sht20.c eeprom.c adc.c irf.c rgb.c
